inherit setuptools3
require botocore.inc