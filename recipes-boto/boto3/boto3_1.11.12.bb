inherit setuptools3
require boto3.inc